# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\touch_key;.\APP\rng;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\pwm_dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\ds18b20;.\APP\hwjs;.\APP\rs485;.\APP\can;.\APP\tftlcd;.\APP\flash;.\APP\spi;.\APP\stm32_flash;.\APP\mpu6050;.\APP\mpu6050\eMPL;.\APP\sram;.\Malloc;.\APP\sd;.\Fatfs;.\Fatfs\fatfs_app;.\Font;.\Picture\BMP;.\USB\USB_APP;.\USB\STM32_USB_Device_Library\Core\inc;.\USB\STM32_USB_Device_Library\Class\msc\inc;.\USB\STM32_USB_OTG_Driver\inc;.\USB\STM32_USB_HOST_Library\Core\inc;.\USB\STM32_USB_HOST_Library\Class\MSC\inc;.\Fatfs\src;.\USB\STM32_USB_HOST_Library\Class\HID\inc;.\Libraries\STM32F4x7_ETH_Driver\inc;.\APP\lan8720;.\LWIP;.\LWIP\arch;.\LWIP\lwip_app\lwip_comm;.\LWIP\lwip_app\tcp_client_demo;.\LWIP\lwip_app\tcp_server_demo;.\LWIP\lwip_app\udp_demo;.\LWIP\lwip_app\web_server_demo;.\LWIP\lwip-1.4.1\src\include;.\LWIP\lwip-1.4.1\src\include\ipv4;.\LWIP\lwip-1.4.1\src\include\lwip;.\LWIP\lwip-1.4.1\src\include\netif
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_rng.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_can.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_sdio.c
    ./Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group APP
    ./APP/led/: led.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/adc/: adc.c
    ./APP/adc_temp/: adc_temp.c
    ./APP/beep/: beep.c
    ./APP/key/: key.c
    ./APP/lan8720/: lan8720.c
    ./APP/rtc/: rtc.c
    ./APP/sram/: sram.c
    ./APP/time/: time.c
  group Malloc
    ./Malloc/: malloc.c
  group LwIP_app
    ./LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ./LWIP/lwip_app/tcp_client_demo/: tcp_client_demo.c
    ./LWIP/lwip_app/tcp_server_demo/: tcp_server_demo.c
    ./LWIP/lwip_app/udp_demo/: udp_demo.c
    ./LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
  group LwIP_netif
    ./LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LwIP_core
    ./LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LwIP_arch
    ./LWIP/arch/: sys_arch.c
  group LwIP_api
    ./LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
